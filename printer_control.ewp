# IAR project printer_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: src\system\STM32F10x_StdPeriph_Driver\inc; src\system\CMSIS\CM3\DeviceSupport\ST\STM32F10x; src\board; src\api; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: stm32f103cbt.out
  ILINK.IlinkIcfFile: linker\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: c.out
  group (top)
    src/board/: board_gpio_table.h
  group src
    src/: main.c main.h
    linker/: stm32f103xB.icf
  group src/board
    src/board/: board_capture.c board_capture.h board_dma.c board_dma.h board_encoder_emulation.c board_encoder_emulation.h board_gpio.c board_gpio.h board_init.c board_init.h board_motor.c board_motor.h board_NVIC.c board_NVIC.h board_pwm.c board_pwm.h board_r_buff.c board_r_buff.h board_spi_dma.c board_spi_dma.h board_state.c board_state.h board_sys_tick.c board_sys_tick.h board_system_type.h board_uart.c board_uart.h
  group src/system/CMSIS
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group src/system/startup
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group src/system/StdPeriph_Driver
    src/system/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
